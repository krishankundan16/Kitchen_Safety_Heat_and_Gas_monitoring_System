# Keil uVision project kitchen_safety.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: kitchen_safety +hex
  c flags: Optim=1
  c include: .\Header_Source_File
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s
    ./C _Source_File/: LCD.c delay_funcdef.c SENSOR.c ADC.c buzzer.c eint0.c event.c KPM.c LM35.c main.c MQ2.c rtc.c Security.c
