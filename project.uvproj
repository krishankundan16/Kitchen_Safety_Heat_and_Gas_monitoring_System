# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: project +hex
  c flags: Optim=1
  c include: .\Header Source File
  asm include: .\Header Source File
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s
    ./C Source File/: ADC.c buzzer.c delay_funcdef.c eint0.c event.c KPM.c LCD.c LM35.c main.c MQ2.c rtc.c Security.c SENSOR.c
