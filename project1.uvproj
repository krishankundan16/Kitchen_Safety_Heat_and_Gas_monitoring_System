# Keil uVision project project1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: project1 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s ADC.h LM35.h buzzer.c LM35.c LCD.c ADC.c buzzer.h rtc.c main.c CONFIG.h SENSOR.c MQ2.c MQ2.h KPM.c delay_funcdef.c
